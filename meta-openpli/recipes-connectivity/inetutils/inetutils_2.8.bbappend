# The --with-path options are not actually options, so this check needs to be silenced
WARN_QA:remove = "unknown-configure-option"
